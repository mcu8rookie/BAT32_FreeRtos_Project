# Keil uVision project iicaMasterSendReceive.uvprojx, settings and files
target BAT32A237 (ARM-ADS)
  device: BAT32A237KH40NB Cmsemicon
  pack: Cmsemicon.BAT32A237.1.0.5
  cpu: CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: iicaMasterSendReceive +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\..\..\Driver\inc
  group Source
    ../: main.c
  group Driver
    ../../../Driver/src/: iica.c iica_user.c sci.c sci_user.c retarget.c
software components: CMSIS:CORE 4.1.0, Device:ISR 1.0.0, Device:Startup 1.0.0

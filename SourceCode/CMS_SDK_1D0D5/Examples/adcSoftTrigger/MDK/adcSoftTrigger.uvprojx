# Keil uVision project adcSoftTrigger.uvprojx, settings and files
target BAT32A237 (ARM-ADS)
  device: BAT32A237KH64FB Cmsemicon
  pack: Cmsemicon.BAT32A237.1.0.2
  cpu: IRAM(0x20000000,0x03000) IROM(0x00000000,0x20000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: adcSoftTrigger
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\..\..\Driver\inc;..\..\..\Driver\src
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x3000
  group Source
    ../: main.c
  group Driver
    ../../../Driver/src/: adc.c dac.c sci.c sci_user.c retarget.c
    ../: adc_user.c
software components: CMSIS:CORE 5.4.0, Device:ISR 1.0.0, Device:Startup 1.0.0

# Keil uVision project BAT32_FreeRTOS_Proj.uvprojx, settings and files
target BAT32_FreeRTOS (ARM-ADS)
  device: BAT32A237KH40NB Cmsemicon
  pack: Cmsemicon.BAT32A237.1.0.2
  cpu: CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: BAT32_FreeRTOS_Proj +hex
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=1
  c include: .\SourceCode;.\SourceCode\UsrCode;.\SourceCode\CMS_SDK_1D0D5\CMSIS\Include;.\SourceCode\CMS_SDK_1D0D5\Device\Include;.\SourceCode\CMS_SDK_1D0D5\Device\Source;.\SourceCode\CMS_SDK_1D0D5\Driver\inc;.\SourceCode\FreeRTOSversion\FreeRTOS\Source\include;.\SourceCode\FreeRTOSversion\FreeRTOS\Source;.\SourceCode\FreeRTOSversion\FreeRTOS\Source\portable\Keil\ARM_CM0P;.\SourceCode\FreeModbus\modbus\include;.\SourceCode\FreeModbus\modbus\rtu;.\SourceCode\FreeModbus\BARE\port;.\SourceCode\FreeModbus\modbus
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x3000
  group MCU_Lib
    ./SourceCode/CMS_SDK_1D0D5/Driver/src/: gpio.c sci.c sci_user.c retarget.c iica.c iica_user.c tima.c tima_user.c
  group FreeRTOS_Lib
    ./SourceCode/FreeRTOSversion/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ./SourceCode/FreeRTOSversion/FreeRTOS/Source/portable/Keil/ARM_CM0P/: port.c
    ./SourceCode/FreeRTOSversion/FreeRTOS/Source/portable/MemMang/: heap_4.c
  group FreeModbus
    ./SourceCode/FreeModbus/modbus/rtu/: mbrtu.c mbcrc.c
    ./SourceCode/FreeModbus/modbus/functions/: mbfunccoils.c mbfuncdiag.c mbfuncdisc.c mbfuncholding.c mbfuncinput.c mbfuncother.c mbutils.c
    ./SourceCode/FreeModbus/BARE/port/: portevent.c portserial.c porttimer.c
    ./SourceCode/FreeModbus/modbus/: mb.c
    ./SourceCode/FreeModbus/BARE/: mb_demo.c
  group UsrCode
    ./SourceCode/UsrCode/: Usr_Main.c Usr_TempCode.c Usr_GPIO.c Usr_Interrupt.c Usr_Uart.c Usr_Task.c Usr_I2C.c Usr_I2CA_Task.c Usr_Soft_I2C.c Usr_ExtSens.c Usr_CRC.c Usr_E703.c Usr_Modbus.c Usr_ALSensor.c Usr_CMP201.c Usr_CPS122.c Usr_HDC2010.c Usr_HDC3020.c
software components: CMSIS:CORE 5.3.0, Device:ISR 1.0.0, Device:Startup 1.0.0
